# IAR project ESC_SSC.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; _ANYID_STM32F4_; _ANYID_HSE12P00_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Device\ST\STM32F4xx\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\STM32F4xx_StdPeriph_Driver\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ESC_SSC.hex
  ILINK.IlinkOutputFile: ESC_SSC.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Build (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _ANYID_STM32F4_; _ANYID_R542_; _ANYID_HSE13P56_
  OBJCOPY.OOCOutputFile: R542.hex
  ILINK.IlinkOutputFile: R542.out
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARMv6
    ../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
  group Main
    ../: AnyID_R542_Config.h main.c stm32f4xx_conf.h stm32f4xx_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Des.c AnyID_Stdlib.c AnyID_SysTick.c
    ../src/: AnyID_FRam.c AnyID_R542_FRam.c AnyID_R542_FRam_HL.c AnyID_R542_IO.c AnyID_R542_IO_HL.c AnyID_R542_Reader.c AnyID_R542_SysCfg.c AnyID_R542_SysTick_HL.c AnyID_R542_WDG_HL.c AnyID_Uart_Receive.c
